# EAGLE board PCB (EAGLE 9.6.2), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
A0
  Top 0.5: U1.36 371.11,101.7 ANALOG.1
A1
  Top 0.5: ANALOG.2 377.94,101.7 376.55,103.09 370.84,103.09 U1.37
A2
  Top 0.5: U1.38 371.22,103.85 377.81,103.85 379.96,101.7 ANALOG.3
A3
  Top 0.5: U1.39 371.6,104.6 379.6,104.6 382.5,101.7 ANALOG.4
A4
  Top 0.5: U1.40 371.98,105.36 381.38,105.36 385.04,101.7 ANALOG.5
A5
  Top 0.5: ANALOG.6 387.58,101.7 383.17,106.11 372.35,106.11 U1.41
COD0  (via drill 0.35)
  Top 0.5: U1.26 357.43,110.36 354.52,107.45 350.39,107.45 348.95,108.89 348.95,116.79 347.63,118.1 v347.2,118.1 | v343.3,119 333.87,119 331.29,121.58 331.29,123.17 330.67,123.8 329.2,123.8 v325.5,127.5 | v304.6,126.58 304.6,125.75 302.27,123.42 300.57,123.42 299.77,122.62 IC1.23
  Bottom 0.5: v347.2,118.1 344.2,118.1 v343.3,119 | v325.5,127.5 305.52,127.5 v304.6,126.58
COD1  (via drill 0.35)
  Top 0.5: U1.25 354.21,108.2 350.7,108.2 349.7,109.2 349.7,117.1 347.3,119.5 v346.6,119.5 | v344.4,120.1 333.83,120.1 332.05,121.89 332.05,123.49 330.93,124.6 329.6,124.6 327.5,126.7 v327.5,126.8 | v310.1,125.9 309.9,125.7 305.7,125.7 302.31,122.31 IC1.22
  Bottom 0.5: v346.6,119.5 345,119.5 v344.4,120.1 | v327.5,126.8 327.43,126.73 310.93,126.73 v310.1,125.9
COD2  (via drill 0.35)
  Top 0.5: U1.12 361.39,120.4 357.39,124.4 351.4,124.4 348.3,121.3 333.7,121.3 332.8,122.2 332.8,123.8 331.2,125.4 330.2,125.4 v329.3,126.3 | v311.2,124.8 306.3,124.8 304.85,123.35 IC1.21
  Bottom 0.5: v329.3,126.3 328.88,125.88 312.28,125.88 v311.2,124.8
COD3  (via drill 0.35)
  Top 0.5: U1.1 370.89,115.84 374.34,115.84 v378.2,119.7 | v368.3,125.7 367.87,125.7 365.68,127.88 352.33,127.88 351.65,127.2 v349.9,127.2 | v314,124.1 312.65,122.75 308.72,122.75 307.39,121.42 IC1.20
  Bottom 0.5: v378.2,119.7 375.9,122 372,122 v368.3,125.7 | v349.9,127.2 349.05,126.35 331.25,126.35 328.7,123.8 318.7,123.8 317.3,125.2 315.1,125.2 v314,124.1
COMMON  (via drill 0.35)
  Top 0.3: v412,118.7 410.4,118.7 409.1,120 406.4,120 405.75,120.65 J1.A5
  Bottom 0.3: R6.1 409.7,116.4 v412,118.7
COMMON2  (via drill 0.35)
  Top 0.3: J1.B5 402.75,120.45 402.3,120 400.3,120 398.1,117.8 v397.4,117.8
  Bottom 0.3: v397.4,117.8 399.5,115.7 R7.1
D+
  Top 0.5: U1.4 369.76,118.1 373.17,118.1 376.7,121.63 376.7,124.93 378.51,126.75 388.59,126.75 393.95,121.39 393.95,118.25 400.91,111.29 404.9,111.29 406.3,109.89 R1.1
D-
  Top 0.5: U1.3 370.14,117.35 373.48,117.35 377.45,121.32 377.45,124.62 378.82,125.99 388.27,125.99 393.19,121.08 393.19,117.94 402.9,108.23 R2.1
DN  (via drill 0.35)
  Top 0.3: J1.A7 404.25,119.66 403.48,118.88 X2.D- | J1.B7 405.25,124.95 v405.2,125
  Bottom 0.3: v405.2,125 404.6,125 403.48,123.88 X2.D-
  Bottom 1: X2.D- 403.48,115.39 R2.2
DP
  Top 0.3: X2.D+ 405.48,118.88 404.75,119.61 J1.A6 404.75,123.65 404.5,123.9 404,123.9 403.75,123.65 J1.B6
  Bottom 1: X2.D+ 405.48,115.63 R1.2
E0  (via drill 0.35)
  Top 0.5: U1.32 359.21,105.28 359.21,103.36 356.3,100.45 v356.3,100.4
  Top 1: D6.A D12.A D18.A D24.A D30.A 144.15,107.97 | 144.15,107.97 D36.A | v350.3,97.8 348.3,95.8 v348.3,95.6 | v343.5,97.3 330.03,97.3 D93.A D89.A D84.A 286.95,101.93 D78.A D72.A D66.A D60.A D54.A D48.A D42.A D36.A | 144.15,107.97 144.15,108.16 D36.A
  Bottom 0.5: v350.3,97.8 350.82,97.8 352.54,99.52 355.42,99.52 v356.3,100.4
  Bottom 1: v348.3,95.6 346.6,97.3 v343.5,97.3
E1  (via drill 0.35)
  Top 0.5: U1.31 358.45,105.66 358.45,104.19 356.87,102.6 v356.8,102.6
  Top 1: D5.A D11.A D17.A D23.A D29.A D35.A D41.A D47.A D53.A D59.A D65.A D71.A D77.A 251.52,99.8 265.8,99.8 267.5,98.1 D83.A 274.23,99.5 281.03,99.5 285.1,95.43 285.1,86.75 288.62,83.23 291.65,83.23 296.29,78.58 D88.A D92.A 329.75,83.65 v329.8,83.7 | v333.8,84.3 334.48,84.98 343.7,84.98 346.37,87.66 346.37,95.87 v350.3,99.8
  Bottom 0.5: v356.8,102.6 354.7,100.5 351,100.5 v350.3,99.8
  Bottom 1: v329.8,83.7 330.4,84.3 v333.8,84.3
E2  (via drill 0.35)
  Top 0.5: U1.30 357.7,106.04 357.7,105 354.9,102.2 v354.8,102.2
  Top 1: D4.A 26.8,78.58 29.3,76.07 31.72,76.07 34.22,78.58 D10.A D16.A D22.A D28.A 116.21,78.58 119.54,81.92 121.96,81.92 125.29,78.58 D34.A D40.A D46.A D52.A D58.A 202.54,78.58 205.04,76.07 207.46,76.07 209.96,78.58 D64.A D70.A 251.19,78.58 254.55,75.21 257.55,75.21 259.67,77.33 259.67,77.95 D76.A 267.99,78.58 271.35,75.21 286.02,75.21 D82.A 301.65,59.58 D87.A D91.A 331.9,61.73 331.9,90.36 337.14,95.6 344.1,95.6 v350.3,101.8
  Bottom 0.5: v354.8,102.2 354.4,101.8 v350.3,101.8
E3  (via drill 0.35)
  Top 0.5: U1.29 356.3,105.77 v356.3,105.4
  Top 1: v350.3,103.8 345.7,99.2 v342.7,99.2 | v294.5,77 291.98,74.48 D81.A | D3.A D9.A D15.A D21.A D27.A D33.A D39.A D45.A D51.A D57.A D63.A D69.A 261.05,59.58 D75.A 267.18,62.08 273.6,68.5 v289,68.5
  Bottom 0.5: v356.3,105.4 356.3,105.3 355.7,104.7 355.7,104.3 354.9,103.5 350.6,103.5 v350.3,103.8
  Bottom 1: v342.7,99.2 339.4,95.9 317.6,95.9 312.8,91.1 312.8,86.5 303.3,77 v294.5,77 | v289,68.5 289,72.18 D81.A
E4  (via drill 0.35)
  Top 0.5: U1.28 354.7,105.3 v354.7,105
  Top 1: D74.A 286.6,45.83 286.6,54.88 D80.A | D86.A 296.55,40.58 293.27,37.29 284.74,37.29 D74.A | D74.A 280.5,41.53 236,41.53 D68.A D62.A 210.8,40.58 207.47,43.92 205.05,43.92 201.72,40.58 D56.A D50.A D44.A D38.A 127.08,40.58 123.88,37.38 D32.A 119.12,37.38 115.5,41 102.47,41 D26.A D20.A D14.A D8.A 34.21,40.58 31.71,38.07 29.29,38.07 26.79,40.58 D2.A
  Bottom 0.5: v354.7,105 353.8,105.9 v350.3,105.9
  Bottom 1: v350.3,105.9 345.3,100.9 342,100.9 340.3,99.2 319,99.2 308.92,89.12 308.92,87.16 303.86,82.09 288.56,82.09 284.67,78.2 284.67,73.55 285.14,73.08 285.14,67.14 283.2,65.2 283.2,62.7 286.32,59.58 D80.A
E5
  Top 0.5: U1.27 353.5,105.23 D55.A
  Top 1: D31.A D25.A D19.A D55.A 348.2,92.28 348.2,40.03 D90.A D85.A D79.A D49.A 277.59,21.58 274.23,18.21 271.23,18.21 267.87,21.58 D73.A 253.79,21.58 250.43,18.21 247.43,18.21 244.07,21.58 D67.A D61.A 212.52,22.71 143.53,22.71 D37.A 142.38,21.58 141.28,22.68 72.25,22.68 D13.A D7.A D1.A
  Bottom 1: D43.A 413.97,65.53 416.57,68.14 416.57,83.71 410.62,89.66 410.62,97.5 D31.A
GND  (via drill 0.35)
  Top 0.3: J1.A1B12 407.75,120.85 v407.7,120.8 | J1.B1A12 401.25,121.35 400.45,120.55 400.07,120.55 398.95,119.43 396.13,119.43 395.35,120.21 395.35,123.55 397.4,125.6 402.5,125.6 403.4,126.5 406.5,126.5 407.8,125.2 416.5,125.2 C1-1UF1.2
  Top 0.5: U1.23 354.44,110.7 v353.3,110.7 352.1,111.9 v351.4,111.9 | U1.15 359.7,118.7 358.3,120.1 v358.3,120.9 | U1.35 366.1,105.57 v366.1,104.8 | U1.43 370.5,110.22 v370.5,110.2 371.8,110.2 379.3,117.7 382.2,117.7 384.6,115.3 384.6,110 | U1.5 370.2,119.67 v370.2,119.7 | C1-22PF2.2 C1-22PF1.2 387.3,107.3 384.6,110 | BUTTON.1 334.45,116.65 v331.9,119.2 | v366.1,104.8 | R4.1 382.79,108.19 384.6,110 | J3.1 329.82,128.23 324.7,128.23 323.4,126.93 v323.4,125 | IC1.18 316.75,124.8 v319.3,124.8 | X2.GND 407.97,118.75 409.13,117.6 414,117.6 C1-1UF2.2
  Top 1: v367,6.4 366.1,6.4 v360,12.5 | v154,126 171,126 v172,125 | v257,124 257.46,124.46 265.54,124.46 v268,122 | v272.5,122.5 277.55,122.5 279.2,124.15 282.7,124.15 284.35,122.5 285.1,122.5 290.9,116.7 292.2,116.7 293.3,117.8 v293.3,120.9 | v12.5,58.7 v9.4,55.6 | v179.7,11.8 184.6,11.8 v185.4,12.6 | v242.3,4.6 275.3,4.6 v278.7,8 | v318.5,110.8 312.47,116.83 IC1.18 | C1-1UF2.2 414.8,117.9 C1-1UF1.2 | R7.2 395.01,107.19 C1-22PF2.2 | R6.2 413.79,107.19 C2-0.1U.2
  Bottom 0.3: v407.7,120.8 407.7,119.06 X2.GND
  Bottom 0.5: BUTTON.1 337.41,111.9 v351.4,111.9 | v331.9,119.2 331.9,120.05 J3.1 | C1-0.1U.2 413.1,101.8 399.6,101.8 394.9,106.5 C1-22PF2.2 | v323.4,125 323.2,124.8 v319.3,124.8
  Bottom 1: v353.3,110.7 358,115.4 358.3,115.4 | 358.3,115.4 v358.3,120.9 | v370.2,119.7 365.9,115.4 365.3,115.4 | 358.3,115.4 365.3,115.4 | 365.3,115.4 v370.5,110.2 370.5,109.2 v366.1,104.8 | v367,6.4 367.02,6.38 374.94,6.38 376.52,7.95 379.51,7.95 381.55,9.99 388.79,9.99 395.01,3.76 414.76,3.76 419,8 419,11 420.5,12.5 LED9.1 424,12.5 429,17.5 429,27 419,37 419,41 420.5,42.5 LED8.1 423,49.2 427.4,53.6 427.4,63.1 420.5,70 420.5,76.5 421.5,77.5 LED7.1 423,79.5 427.5,84 427.5,95.5 425.5,97.5 419.8,97.5 C1-0.1U.2 C2-0.1U.2 C3-0.1U.2 C1-1UF2.2 | v154,126 133,126 126.5,119.5 LED2.1 119,119.5 112.5,126 48,126 41.56,119.56 LED1.1 30.43,119.5 27.2,119.5 12.2,104.5 | v172,125 197.5,125 203,119.5 LED3.1 212,119.5 218,125.5 255.5,125.5 v257,124 | v268,122 272,122 v272.5,122.5 | LED16.1 12.2,104.5 | 12.2,104.5 17.7,99 17.7,94.7 19.3,93.1 19.3,79.8 28.7,70.4 28.7,66.6 20.9,58.8 | v12.5,58.7 12.6,58.8 20.9,58.8 | v9.4,55.6 9.4,52.6 8.3,51.5 LED15.1 | 20.9,58.8 24.6,58.8 31.3,52.1 31.3,47 28.4,44.1 21.6,44.1 19.1,41.6 19.1,38.7 26.2,31.6 26.2,14.3 LED14.1 29.5,12.5 31,11 31,9.7 32,8.7 82.3,8.7 86.1,12.5 LED13.1 99.5,12.5 103.1,8.9 162.1,8.9 165.7,12.5 LED12.1 179,12.5 v179.7,11.8 | v185.4,12.6 193,5 236.42,5 238.29,3.12 240.71,3.12 242.18,4.6 v242.3,4.6 | v278.7,8 271.5,8 267,12.5 LED11.1 | LED5.1 387.5,118.5 385.7,116.7 385.7,110.8 C1-22PF1.2 | v293.3,120.9 293.3,120.92 296.84,124.46 | 296.84,124.46 297.5,125.12 LED4.1 | LED10.1 v360,12.5 | IC1.18 IC1.19 309.93,123.07 308.54,124.46 296.84,124.46 | IC1.12 325.17,106.56 320.93,110.8 v318.5,110.8 | C1-1UF1.2 421.7,122.4 423.7,120.4 LED6.1
LEDS  (via drill 0.35)
  Top 1: v422.2,6.3 420.9,7.6 418.2,7.6 415.2,4.6 389.2,4.6 383.75,10.05 381.62,10.05 379.1,7.53 369.9,7.53 367.52,5.15 365.58,5.15 362.97,7.76 361.87,7.76 360.03,9.6 v355.3,9.6 351.4,9.6 v345.3,3.5 | v266.5,24.7 268,26.2 v270.1,26.2 | v277,24.6 291.7,24.6 v293.2,23.1 | v295.5,19.5 296,20 307.5,20 v309.2,18.3 | v314.3,22.9 v318,22.9 | v350,17.7 348.3,17.7 345.2,20.8 334.2,20.8 331.9,18.5 328.2,18.5 v327.2,17.5 | v421.2,37.1 421.2,32.1 427.72,25.58 427.72,21 425.45,18.74 v423.3,18.74 | v418.4,13 420.5,10.9 v420.5,9.5 | v420.5,40.2 420.5,50.1 428.7,58.3 v428.7,58.4 | v425.9,75.4 423,78.3 423,81.8 427.5,86.3 427.5,97 429.9,99.4 429.9,117.01 R3.1 427.4,114.87 LEDSJUMPER.1 | v416.7,114.3 413.2,114.3 408,109.1 408,105.7 406.3,104 v405.2,104 | v252.7,8.5 245,8.5 v244.8,8.7 | v225.3,23.1 v222.1,23.1 | v201.8,9.1 179.7,9.1 v178.3,10.5 | v85.8,9.8 83.4,9.8 82.3,8.7 33.2,8.7 31.8,7.3 v30.7,7.3 | v3.6,72.8 3.6,95.3 v6.1,97.8 | v13.7,100.5 19,105.8 v25.3,105.8 | v36.9,115.6 39.8,112.7 v119.9,112.7 | v124.7,116.9 128.4,113.2 v204.8,113.2 | v334.8,4.4 292.8,4.4 291.21,5.99 291.21,7.29 289.44,9.06 286.94,9.06 284.63,6.75 v281.75,6.75 | v302.5,127.8 296,127.8 294.6,126.4 288.5,126.4 v287.3,125.2 | v210.3,114.5 216.3,114.5 217.27,113.53 228.93,113.53 v229.8,114.4 | v263.6,120.4 266.3,117.7 266.3,115.2 264.1,113 252.3,113 250.9,114.4 250.9,121.5 v249.1,123.3
  Bottom 1: v422.2,6.3 423,7.1 LED9.2 v420.5,9.5 | v355.3,9.6 352.1,9.6 LED10.2 350,9.5 349.1,10.4 349.1,16.8 v350,17.7 | v266.5,24.7 266.5,17.02 263,13.52 263,9.9 263.4,9.5 | v270.1,26.2 270.68,26.2 271.24,26.77 274.83,26.77 v277,24.6 | v293.2,23.1 295.5,20.8 v295.5,19.5 | v309.2,18.3 311.5,18.3 314.3,21.1 v314.3,22.9 | v327.2,17.5 321.8,22.9 v318,22.9 | v421.2,37.1 423,38.9 LED8.2 421.2,39.5 v420.5,40.2 | v423.3,18.74 422.54,18.74 421.3,17.5 418.3,17.5 416.9,16.1 416.9,14.5 v418.4,13 | v425.9,75.4 425,74.5 LED7.2 423,69.8 428.7,64.1 v428.7,58.4 | v416.7,114.3 423.3,114.3 423.7,114.7 LED6.2 423.7,111.77 LEDSJUMPER.1 | LED5.2 391.3,114.2 391.3,111.3 392.7,109.9 395.6,109.9 397,108.5 397,106.8 399.8,104 v405.2,104 | 263.4,9.5 LED11.2 268.23,9.5 270.98,6.75 v281.75,6.75 | 263.4,9.5 253.7,9.5 v252.7,8.5 | v244.8,8.7 243.7,8.7 229.3,23.1 v225.3,23.1 | v222.1,23.1 218.7,19.7 218.7,12.5 214.7,8.5 202.4,8.5 v201.8,9.1 | v178.3,10.5 177.3,9.5 LED12.2 164.47,9.5 162.62,7.65 102.52,7.65 100.67,9.5 LED13.2 86.1,9.5 v85.8,9.8 | v30.7,7.3 30.2,7.3 LED14.2 27.47,8.97 8.03,8.97 3.7,13.3 3.7,46.2 LED15.2 4.6,48.5 3.6,49.5 v3.6,72.8 | v6.1,97.8 6.1,101.4 LED16.2 12.7,101.5 v13.7,100.5 | v25.3,105.8 30.49,110.99 LED1.2 35.94,116.56 v36.9,115.6 | v119.9,112.7 121,113.8 LED2.2 124.3,116.5 v124.7,116.9 | v204.8,113.2 206.5,114.9 LED3.2 209.5,116.5 210.3,115.7 v210.3,114.5 | v345.3,3.5 335.7,3.5 v334.8,4.4 | LED4.2 301.5,127 302.3,127.8 v302.5,127.8 | v287.3,125.2 286.6,125.9 285.62,125.9 277.5,125.9 275.8,124.2 267.4,124.2 v263.6,120.4 | v229.8,114.4 227.9,116.3 227.9,120.2 231.95,124.25 248.15,124.25 v249.1,123.3
MISO
  Top 0.5: U1.11 366.5,122.76 366.5,123.7 365,125.2 347.21,125.2 J3.5
MOSI
  Top 0.5: U1.10 364.71,119.9 367.45,122.64 367.45,123.91 365.27,126.1 343.8,126.1 342.57,124.87 J3.4
MUX0  (via drill 0.35)
  Top 1: v278.95,102.51 278.56,102.92 19.46,102.92 7.69,91.14 U$5.SW1
  Bottom 1: U$6.SW1 7.14,119.09 5.53,119.09 2.33,115.89 2.33,96.4 U$5.SW1 7.19,90.54 5.58,90.54 4.38,89.34 4.38,80.1 U$4.SW1 11.99,71.49 10.38,71.49 9.18,70.3 9.18,58.65 U$3.SW1 14.29,52.54 12.68,52.54 11.48,51.34 11.48,35.43 U$2.SW1 9.59,33.54 7.97,33.54 6.78,32.34 6.78,18.35 U$1.SW1 | IC1.1 281.73,105.28 v278.96,102.51 v278.95,102.51
MUX1  (via drill 0.35)
  Top 1: v238.83,111.61 v258.89,111.61 287.43,111.61 290.74,108.3 298.4,108.3 299.77,106.93 IC1.2 | v233.5,111.61 125.03,111.61 112.17,124.46 50.41,124.46 45.71,119.76 U$12.SW1 | v312.19,47.34 303.1,47.34 300.27,44.52 v287.11,44.52 | v276.76,44.52 267.36,53.92 265.16,53.92 v262.03,57.06
  Bottom 1: U$7.SW1 33.48,15.05 33.48,25.08 28.16,30.41 28.16,32.6 29.41,33.86 31.29,33.86 U$8.SW1 31.6,34.48 33.48,36.37 33.48,47.34 39.13,52.98 | 39.13,52.98 40.7,52.98 U$9.SW1 | 32.86,70.22 34.42,71.79 35.99,71.79 U$10.SW1 | 32.86,70.22 32.86,59.25 39.13,52.98 | 32.86,70.22 32.54,70.54 31.6,70.54 23.14,79 23.14,89.35 24.71,90.92 26.59,90.92 U$11.SW1 26.9,91.23 26.9,102.51 43.83,119.44 45.4,119.44 U$12.SW1 | v233.5,111.61 v238.83,111.61 | v312.19,47.34 315.32,44.2 335.38,44.2 345.42,34.17 358.9,34.17 DUPLICADO1.SW1 | v276.76,44.52 v287.11,44.52 | v262.03,57.06 262.03,58.94 256.38,64.58 256.38,73.36 252.31,77.43 252.31,105.02 v258.89,111.61
MUX2  (via drill 0.35)
  Top 1: v340.07,27.9 367.68,27.9 373.63,33.86 378.02,33.86 DUPLICADO2.SW1 | U$16.SW1 55.43,72.11 56.06,72.11 60.76,76.81 81.76,76.81 89.92,68.66 89.92,68.04 94.93,63.03 262.13,63.03 266.7,67.6 270.93,67.6 273.08,69.75 273.16,69.75 v276.13,72.73
  Bottom 1: 58.25,52.98 56.37,51.1 56.37,48.91 50.73,43.26 50.73,34.17 U$14.SW1 50.1,33.86 48.53,33.86 46.97,32.29 46.97,30.72 57.31,20.38 57.31,15.05 U$13.SW1 | 58.25,52.98 59.82,52.98 U$15.SW1 | 53.24,71.79 55.12,71.79 U$16.SW1 | 53.24,71.79 51.67,70.22 51.67,59.56 58.25,52.98 | 53.24,71.79 42.26,82.76 42.26,89.35 43.83,90.92 45.4,90.92 U$17.SW1 45.71,91.54 45.71,102.2 62.95,119.44 64.52,119.44 U$18.SW1 | v340.07,27.9 338.52,27.9 324.73,41.7 314.07,41.7 309.05,46.71 296.82,46.71 281.15,62.39 281.15,67.72 v276.13,72.73 276.13,86.63 282.84,93.34 282.84,100.64 285.9,103.7 295.45,103.7 296.44,102.7 301.16,102.7 302.31,103.86 IC1.3
MUX3  (via drill 0.35)
  Top 1: v306.52,94.18 313.14,94.18 314.58,95.62 323.79,95.62 327.86,91.54 327.86,83.08 v328.49,82.45 | U$23.SW1 64.83,91.23 65.78,91.23 70.17,95.62 129.42,95.62 140.07,84.96 233.19,84.96 235.69,82.45 249.22,82.45 251.52,84.75 259.58,84.75 264.49,79.83 268.51,79.83 271.64,76.7 v282.5,76.7 | v310.3,112.9 303.9,112.9 v302.2,111.2
  Bottom 1: 77.06,52.98 75.49,51.41 75.49,48.91 69.54,42.95 69.54,34.17 U$20.SW1 | 77.06,52.98 78.94,52.98 U$21.SW1 | 72.36,71.79 74.24,71.79 U$22.SW1 | 72.36,71.79 70.79,70.22 70.79,64.89 76.75,58.94 76.75,53.3 77.06,52.98 | 72.36,71.79 61.39,82.76 61.39,89.35 62.95,90.92 64.52,90.92 U$23.SW1 65.15,91.23 65.15,102.83 81.76,119.44 83.64,119.44 U$24.SW1 | 374.57,82.14 374.57,89.03 376.45,90.92 378.02,90.92 U$19.SW1 | 374.57,82.14 374.57,49.85 376.14,48.28 377.71,48.28 391.81,34.17 397.14,34.17 DUPLICADO3.SW1 | v328.49,82.45 329.43,82.45 329.74,82.14 374.57,82.14 | v282.5,76.7 282.5,77.91 283.39,78.8 283.39,81.19 289.62,87.41 289.62,98.84 291.53,100.75 301.18,100.75 304.82,104.4 304.82,105.25 | 304.82,105.25 IC1.4 | v306.52,94.18 306.55,94.21 306.55,98.25 309.4,101.1 325.6,101.1 327,102.5 327,106.5 320.6,112.9 v310.3,112.9 | v302.2,111.2 304.82,108.58 304.82,105.25
MUX4  (via drill 0.35)
  Top 1: DUPLICADO4.SW1 359.21,53.3 359.21,56.12 388.05,84.96 391.5,84.96 393.7,87.15 393.7,89.35 395.26,90.92 397.14,90.92 U$25.SW1 | v296.17,94.59 296.16,94.58 288.18,94.58 | 288.18,94.58 281.5,101.26 v110.29,101.26 | v345.42,42.32 345.42,41.07 v331.62,27.27 | v283.2,89.5 277.7,89.5 v274.8,92.4 | v287,89.5 288.18,90.68 288.18,94.58
  Bottom 1: 96.19,52.98 94.62,51.41 94.62,49.22 88.66,43.26 88.66,34.17 U$26.SW1 | 96.19,52.98 97.75,52.98 U$27.SW1 | 91.17,71.79 93.05,71.79 U$28.SW1 | 91.17,71.79 89.6,70.22 89.6,59.56 96.19,52.98 | 91.17,71.79 80.2,82.76 80.2,89.35 81.76,90.92 83.64,90.92 U$29.SW1 83.64,91.54 83.64,102.2 96.5,115.06 | 96.5,115.06 100.89,119.44 102.45,119.44 U$30.SW1 | 96.5,115.06 v110.29,101.26 | v345.42,42.32 356.08,52.98 358.9,52.98 DUPLICADO4.SW1 | v331.62,27.27 331.62,19.12 327.24,14.73 327.24,13.48 327.55,13.17 327.55,11.6 324.93,8.98 296.62,8.98 289.3,16.3 289.3,28.21 271.84,45.68 271.84,55.08 267.67,59.25 267.67,64.17 271.84,68.34 271.84,76.4 260.77,87.47 260.77,93.42 263.45,96.1 272.7,96.1 274.8,94 v274.8,92.4 | v283.2,89.5 v287,89.5 | IC1.5 307.36,105.25 307.36,102.77 301.8,97.2 298.78,97.2 v296.17,94.59
MUX5  (via drill 0.35)
  Top 1: v133.18,106.28 v260.46,106.28 | v372.69,58.62 378.02,53.3 DUPLICADO5.SW1 | v309.99,76.81 v328.49,76.81 | v308.11,79.94 301.45,79.94 v297.83,83.56 | v303.9,101.5 308,101.5 309.93,103.43 IC1.6
  Bottom 1: DUPLICADO5.SW1 378.33,53.3 378.33,57.68 383.85,63.2 387.7,63.2 391.4,66.9 391.4,74.1 396.4,79.1 401.8,79.1 406.86,84.16 406.86,86.21 408.75,88.09 408.75,98.13 410,99.38 411.25,99.38 415.95,94.68 415.95,91.23 U$31.SW1 | 115.31,52.98 113.43,51.1 113.43,48.91 107.47,42.95 107.47,34.17 U$32.SW1 | 115.31,52.98 116.88,52.98 U$33.SW1 | 110.29,71.79 112.17,71.79 U$34.SW1 | 110.29,71.79 108.72,70.22 108.72,59.56 115.31,52.98 | 110.29,71.79 99.32,82.76 99.32,89.35 100.89,90.92 102.45,90.92 U$35.SW1 102.77,91.54 117.82,106.59 117.82,107.84 124.71,114.74 | 124.71,114.74 129.42,119.44 130.98,119.44 U$36.SW1 | v260.46,106.28 267.04,112.86 278.33,112.86 279.58,114.11 303.89,114.11 309.93,108.07 IC1.6 | 124.71,114.74 v133.18,106.28 | v372.69,58.62 372.69,70.54 366.42,76.81 355.14,76.81 352.94,74.61 344.79,74.61 342.6,76.81 v328.49,76.81 | v309.99,76.81 308.11,78.69 v308.11,79.94 | v297.83,83.56 294,87.39 294,95.2 298.1,99.3 301.7,99.3 v303.9,101.5
MUX6  (via drill 0.35)
  Top 1: v377.71,37.93 392.76,52.98 397.14,52.98 DUPLICADO6.SW1 | v329.43,40.76 316.26,40.76 v314.69,39.19 | v303.41,27.9 301.21,27.9 299.02,25.71 297.29,25.71 295.85,27.15 273.08,27.15 272.38,27.85 264.52,27.85 263.4,26.73 258.8,26.73 257.68,27.85 239.42,27.85 238.28,26.71 165.09,26.71 152.93,38.87 131.3,38.87 126.59,34.17 U$38.SW1 | v294.9,124.5 294.9,118.8 v296.4,117.3
  Bottom 1: U$37.SW1 128.79,15.05 128.79,24.77 122.83,30.72 122.83,32.29 124.4,33.86 126.28,33.86 U$38.SW1 126.59,34.48 132.24,40.13 132.24,51.1 134.12,52.98 | 134.12,52.98 135.69,52.98 U$39.SW1 | 129.1,71.79 130.98,71.79 U$40.SW1 | 129.1,71.79 127.85,70.54 127.85,59.25 134.12,52.98 | 129.1,71.79 124.09,76.81 124.09,79.94 118.13,85.9 118.13,89.35 119.7,90.92 121.58,90.92 U$41.SW1 121.58,91.54 121.58,92.8 148.23,119.44 150.11,119.44 U$42.SW1 150.42,119.76 157.94,127.28 293.52,127.28 294.9,125.9 v294.9,124.5 | v377.71,37.93 367.68,27.9 349.81,27.9 336.95,40.76 v329.43,40.76 | v303.41,27.9 v314.69,39.19 | v296.4,117.3 298.03,115.67 304.4,115.67 312.44,107.63 312.44,105.31 IC1.7
MUX7  (via drill 0.35)
  Top 1: v418.86,75.89 408.75,86 408.75,91.54 404.67,95.62 395.26,95.62 389.94,90.29 389.94,88.41 387.74,86.21 387.43,86.21 386.17,84.96 373,84.96 360.15,72.11 359.52,72.11 DUPLICADO7.SW1 | U$48.SW1 169.23,119.76 176.75,127.28 283.03,127.28 291.5,118.81 v291.5,117.96 | v336.01,58 330.37,58 330.06,57.68 300.27,57.68 290.87,67.09 v279.9,67.09 | v289.63,111.31 293.2,114.88 v293.2,115.8 | v295.6,115.7 309.6,115.7 315.01,110.29 IC1.8
  Bottom 1: U$43.SW1 418.86,65.11 v418.86,75.89 | 153.24,52.98 151.36,51.1 151.36,48.91 145.72,43.26 145.72,34.17 U$44.SW1 | 153.24,52.98 154.81,52.98 U$45.SW1 | 148.23,71.79 150.11,71.79 U$46.SW1 | 148.23,71.79 146.66,70.22 146.66,59.56 153.24,52.98 | 148.23,71.79 137.25,82.76 137.25,89.35 138.82,90.92 140.39,90.92 U$47.SW1 140.7,91.54 140.7,92.8 167.35,119.44 168.92,119.44 U$48.SW1 | v336.01,58 349.81,71.79 359.21,71.79 DUPLICADO7.SW1 | v279.9,67.09 274.68,72.31 274.68,86.95 276.76,89.03 276.76,102.2 285.87,111.31 v289.63,111.31 | v293.2,115.8 293.16,115.8 291.5,117.46 v291.5,117.96 293.34,117.96 v295.6,115.7
MUX8  (via drill 0.35)
  Top 1: DUPLICADO8.SW1 378.33,72.11 379.28,72.11 390.88,83.7 394.64,83.7 396.52,85.58 398.71,85.58 408.43,75.87 414.9,75.87 429.97,60.8 429.97,56.14 422.91,49.09 422.91,33.07 428.97,27.01 428.97,20.41 426.05,17.48 406.62,17.48 400.11,24 358.76,24 355.56,20.8 354.9,20.8 352.15,18.05 352.15,15.79 344,7.64 325.36,7.64 323.99,6.27 295.23,6.27 293.4,8.1 v293.1,8.1 | v280.21,112.86 273.63,112.86 270.18,116.31 270.18,122.19 266.65,125.71 219.7,125.71 214.38,120.38 204.97,120.38 201.21,124.15 193.68,124.15 189.29,119.76 188.35,119.76 U$54.SW1 | v312.2,110.4 307.3,110.4 v306.3,109.4
  Bottom 1: 172.05,52.98 170.48,51.41 170.48,48.91 164.53,42.95 164.53,34.17 U$50.SW1 | 172.05,52.98 173.93,52.98 U$51.SW1 | 167.35,71.79 169.23,71.79 U$52.SW1 | 167.35,71.79 165.78,70.22 165.78,59.25 172.05,52.98 | 167.35,71.79 156.38,82.76 156.38,89.35 157.94,90.92 159.51,90.92 U$53.SW1 160.14,91.23 160.14,93.11 186.47,119.44 188.04,119.44 U$54.SW1 | 271.12,18.18 271.12,15.05 U$49.SW1 | 271.12,18.18 268.3,21 268.3,33.86 265.48,36.68 265.48,42.95 261.71,46.71 261.71,54.86 265.16,58.31 265.16,67.09 261.71,70.54 261.71,77.43 262.03,77.75 262.03,84.33 259.52,86.84 259.52,99.82 265.4,105.7 271.17,105.7 277.07,111.61 280.21,111.61 | 280.21,111.61 284.29,111.61 285.54,112.86 302.84,112.86 v306.3,109.4 | 271.12,18.18 274.25,18.18 275.82,19.75 282.36,19.75 286.79,15.31 286.79,11.71 290.4,8.1 v293.1,8.1 | 280.21,111.61 v280.21,112.86 | v312.2,110.4 313.8,110.4 317.55,106.65 IC1.9
MUX9  (via drill 0.35)
  Top 1: v188.67,48.28 189.61,49.22 189.61,51.41 191.18,52.98 192.74,52.98 U$57.SW1 | v397.14,84.33 397.14,72.11 DUPLICADO9.SW1 | U$60.SW1 216.88,119.76 221.59,124.46 225.97,124.46 231.62,118.82 231.62,116.94 238.6,109.95 287.31,109.95 288.67,108.58 288.67,107.53 296.84,99.37 v313.38,99.37 316.01,102 319,102 320.09,103.09 IC1.10 | v355.14,78.69 355.14,88.72 357.33,90.92 359.21,90.92 U$55.SW1 | v328.49,80.26 311.9,80.26 v311.37,80.78 | v311.87,83.7 308.65,86.93 v308.65,91.23
  Bottom 1: v188.67,48.28 183.65,43.26 183.65,34.17 U$56.SW1 | 186.16,71.79 188.04,71.79 U$58.SW1 | 186.16,71.79 184.91,70.54 184.91,64.58 192.74,56.74 192.74,53.3 U$57.SW1 | 186.16,71.79 185.85,72.11 185.85,78.06 183.65,80.26 182.71,80.26 175.19,87.78 175.19,89.35 176.88,91.04 U$59.SW1 188.65,101 202,101 212,111 212,116.52 214.57,119.09 216.22,119.09 216.57,119.44 U$60.SW1 | v397.14,84.33 385.86,95.62 364.54,95.62 360.15,91.23 359.52,91.23 U$55.SW1 | v355.14,78.69 352.31,75.87 345.42,75.87 341.03,80.26 v328.49,80.26 | v311.87,83.7 311.37,83.2 v311.37,80.78 | v308.65,91.23 308.65,98.43 309.58,99.37 v313.38,99.37
MUX10  (via drill 0.35)
  Top 1: v312.86,96.23 312.56,95.93 288.82,95.93 280.23,104.52 236.82,104.52 v236.32,105.02 | DUPLICADO10.SW1 368.93,15.05 369.56,15.05 374.26,19.75 378.96,19.75 383.66,15.05 397.14,15.05 PUNTODUPLICADO.SW1 | v278.64,55.18 265.79,55.18 262.65,58.31 245.72,58.31 245.1,57.68 216.57,57.68 212.18,53.3 U$63.SW1 | v315.9,99.3 317.2,100.6 319.7,100.6 322.63,103.53 IC1.11
  Bottom 1: v236.32,105.02 236.32,106.9 232.24,110.98 | 232.24,110.98 232.24,117.88 233.81,119.44 235.38,119.44 U$66.SW1 | U$61.SW1 199.95,15.05 199.95,29.78 199.01,30.72 199.01,32.29 200.58,33.86 202.15,33.86 U$62.SW1 202.46,34.48 202.46,41.38 208.42,47.34 208.42,51.1 210.3,52.98 | 210.3,52.98 211.87,52.98 U$63.SW1 | 205.28,71.79 207.16,71.79 U$64.SW1 | 205.28,71.79 203.72,70.22 203.72,59.56 210.3,52.98 | 205.28,71.79 204.97,72.11 204.97,73.05 194.31,83.7 194.31,89.35 195.88,90.92 197.45,90.92 U$65.SW1 198.07,91.23 217.51,110.67 231.93,110.67 232.24,110.98 | v278.64,55.18 281.04,55.18 288.57,47.65 294,47.65 296.2,45.46 308.43,45.46 313.44,40.44 324.1,40.44 331.31,33.23 331.31,31.35 337.27,25.39 370.18,25.39 380.53,15.05 397.14,15.05 PUNTODUPLICADO.SW1 | v312.86,96.23 312.86,96.26 v315.9,99.3
MUX11  (via drill 0.35)
  Top 0.5: v284.9,123.8 282.7,126 v275.3,126 | v313.7,117.4 318.7,117.4 v318.8,117.5
  Bottom 0.5: v275.3,126 262.2,126 255.79,119.59 U$72.SW1 | v284.9,123.8 289.7,119 296.22,119 297.82,117.4 v313.7,117.4 | v318.8,117.5 323.75,117.5 325.17,118.92 IC1.13
  Bottom 1: U$67.SW1 223.78,15.05 223.78,24.77 218.14,30.41 218.14,32.6 219.39,33.86 221.27,33.86 U$68.SW1 221.59,34.48 221.59,47.97 226.6,52.98 | 226.6,52.98 230.99,52.98 U$69.SW1 | 224.09,71.79 225.97,71.79 U$70.SW1 | 224.09,71.79 222.84,70.54 222.84,56.74 226.6,52.98 | 224.09,71.79 223.78,72.11 223.78,73.05 213.12,83.7 213.12,89.35 214.69,90.92 216.57,90.92 U$71.SW1 216.88,91.54 224.72,99.38 232.56,99.38 252.72,119.54 254.6,119.54 254.66,119.59 U$72.SW1
MUX12  (via drill 0.35)
  Top 0.5: v306.7,123 307.3,123.6 311.7,123.6 314.3,126.2 319.8,126.2 322.6,123.4 322.6,120.55 IC1.14
  Top 1: v241.65,66.78 241.65,70.22 243.22,71.79 245.1,71.79 U$76.SW1
  Bottom 0.5: U$78.SW1 279,124.9 285.2,124.9 290.3,119.8 293.7,119.8 296.9,123 v306.7,123
  Bottom 1: 255.13,33.86 253.56,32.29 253.56,21 247.61,15.05 U$73.SW1 | 255.13,33.86 257.01,33.86 U$74.SW1 | 248.23,52.98 249.8,52.98 U$75.SW1 | 248.23,52.98 246.66,51.41 246.66,47.81 254.82,39.66 254.82,34.17 255.13,33.86 | U$76.SW1 245.1,72.11 243.84,72.11 232.24,83.7 232.24,89.35 233.81,90.92 235.69,90.92 U$77.SW1 236.01,91.23 236.63,91.23 258.89,113.49 265.79,113.49 271.75,119.44 273.63,119.44 U$78.SW1 | v241.65,66.78 247.92,60.51 247.92,53.3 248.23,52.98
MUX13  (via drill 0.35)
  Top 1: U$83.SW1 263.91,90.92 262.34,90.92 260.77,89.35 260.77,87.47 262.03,86.21 v263.91,86.21 265.16,84.96 282.84,84.96 284.78,83.02 v284.78,80.36 284.78,79.44 288.36,75.86 288.36,74.93 291.18,72.11 297.14,72.11 U$81.SW1 | v293.17,86.26 293.97,87.06 293.97,89.32 295.57,90.92 297.45,90.92 U$84.SW1 | 294,47.65 294,51.41 295.57,52.98 297.45,52.98 U$80.SW1 | 294,47.65 v294,45.77 | U$79.SW1 297.14,14.73 295.26,14.73 294,13.48 294,11.6 296.82,8.78 305.6,8.78 308.43,11.6 308.43,14.73 313.54,19.85 331.48,19.85 333.68,22.05 355.04,22.05 358.24,25.25 400.62,25.25 403.48,22.4 412.1,22.4 414.19,24.49 ENTERDUPLICADO.SW1 | v294,61.13 294,55.18 289.62,50.79 289.62,48.59 290.56,47.65 294,47.65 | v323.9,102.35 325.85,102.35 327.5,104 327.5,106 320.09,113.41 IC1.15
  Bottom 1: U$82.SW1 273.22,64.47 273.22,76.9 v263.91,86.21 | v293.17,86.26 v293.16,86.26 291.75,84.85 289.07,84.85 284.78,80.56 v284.78,80.36 | v294,45.77 297.14,42.64 297.14,15.05 U$79.SW1 | v294,61.13 294,70.22 295.57,71.79 297.14,71.79 U$81.SW1 | U$84.SW1 297.51,91.04 308.82,102.35 v323.9,102.35
MUX14  (via drill 0.35)
  Top 1: 313.44,46.71 313.44,37.62 309.05,33.23 309.05,29.78 310.31,28.53 311.25,28.53 313.13,30.41 313.13,32.6 314.38,33.86 316.26,33.86 U$86.SW1 | 313.44,46.71 313.44,47.97 313.13,48.28 313.13,51.41 314.69,52.98 316.26,52.98 U$87.SW1 | v313.13,61.13 313.13,70.54 314.38,71.79 316.26,71.79 U$88.SW1 | v313.83,83.29 313.83,85.19 312.83,86.19 312.83,89.35 314.39,90.92 316.26,90.92 U$89.SW1 | v346.67,83.39 346.67,66.78 336.64,56.74 333.5,56.74 327.55,50.79 327.55,49.53 324.73,46.71 313.44,46.71
  Bottom 1: U$85.SW1 316.26,15.05 316.26,27.27 313.13,30.41 313.13,32.6 314.38,33.86 316.26,33.86 U$86.SW1 | v313.13,61.13 313.13,56.43 316.26,53.3 U$87.SW1 | v313.83,83.29 316.26,80.86 316.26,72.11 U$88.SW1 | v346.67,83.39 359.21,95.93 359.21,106.28 357.02,108.47 341.07,108.47 339.1,106.5 331.17,106.5 322.12,115.55 318.65,115.55 317.55,116.65 IC1.16
MUX15  (via drill 0.35)
  Top 1: v330.06,32.6 330.06,39.5 331.94,41.38 331.94,51.41 333.5,52.98 335.38,52.98 U$91.SW1
  Bottom 1: U$90.SW1 338.19,17.79 338.19,22.59 330.06,30.72 v330.06,32.6 | 331.94,66.78 331.94,56.74 335.38,53.3 U$91.SW1 | 331.94,66.78 331.94,70.22 333.5,71.79 335.38,71.79 U$92.SW1 | 331.31,86.53 330.37,85.58 329.74,85.58 327.24,83.08 327.24,70.54 327.86,69.91 327.86,68.03 329.12,66.78 331.94,66.78 | 331.31,86.53 331.62,86.84 331.62,89.03 333.5,90.92 335.38,90.92 U$93.SW1 | 331.31,86.53 331.62,86.21 333.82,86.21 335.07,84.96 343.85,84.96 357.96,99.07 357.96,105.65 356.39,107.22 341.59,107.22 339.62,105.25 330.35,105.25 321.3,114.3 317.2,114.3 315.01,116.49 IC1.17
N$1
  Top 1: D4.C 19.94,74.53 U$4.SW2
N$2
  Top 1: D10.C 43.69,74.53 U$10.SW2
N$3
  Top 1: D16.C 62.69,74.53 U$16.SW2
N$4
  Top 1: D22.C 81.69,74.53 U$22.SW2
N$5
  Top 1: D5.C 15.14,93.58 U$5.SW2
N$6
  Top 1: D6.C 16.95,122.13 U$6.SW2
N$7
  Top 1: D28.C 100.69,74.53 U$28.SW2
N$8
  Top 1: D34.C 119.69,74.53 U$34.SW2
N$9
  Top 1: D40.C 138.69,74.53 U$40.SW2
N$10
  Top 1: D46.C 157.69,74.53 U$46.SW2
N$11  (via drill 0.35)
  Top 1: D11.C 34.14,93.58 U$11.SW2 | v334.58,24.29 339.65,29.36 341.23,29.36 348.24,36.37 365.48,36.37 DUPLICADO1.SW2 | v328.49,14.11 328.49,12.54 323.47,7.52 295.75,7.52 293.77,9.5 290.77,9.5 289.96,10.31 286.42,10.31 285.61,9.5 278,9.5 275.7,7.2 244.17,7.2 231.62,19.75 188.04,19.75 183.97,15.68 140.07,15.68 136,19.75 88.03,19.75 83.96,15.68 68.91,15.68 64.52,20.06 v52.92,20.06
  Bottom 1: v334.58,24.29 336.88,21.98 336.88,20.3 330.69,14.11 v328.49,14.11 | v52.92,20.06 43.2,29.78 43.2,41.07 50.41,48.28 50.73,48.28 51.98,49.53 51.98,57.37 47.28,62.07 47.28,75.87 40.38,82.76 40.38,87.15 D11.C
N$12
  Top 1: D12.C 54.9,122.18 U$12.SW2
N$13
  Top 1: D52.C 176.69,74.53 U$52.SW2
N$14
  Top 1: D58.C 195.69,74.53 U$58.SW2
N$15
  Top 1: D64.C 214.69,74.53 U$64.SW2
N$16
  Top 1: D70.C 233.69,74.53 U$70.SW2
N$17  (via drill 0.35)
  Top 1: D17.C 53.14,93.58 U$17.SW2 | v363.91,41.07 368.3,36.68 384.29,36.68 DUPLICADO2.SW2 | v342.28,41.07 327.86,26.65 v313.13,26.65 | v190.55,39.19 201.78,27.96 237.76,27.96 238.9,29.1 258.2,29.1 259.32,27.98 262.88,27.98 264,29.1 272.9,29.1 273.6,28.4 296.95,28.4 v298.39,26.96 | v186.16,43.58 122.21,43.58 117.5,48.28 115,48.28 105.59,57.68 v72.99,57.68
  Bottom 1: v363.91,41.07 355.45,41.07 352.31,44.2 349.18,44.2 346.05,41.07 v342.28,41.07 | v313.13,26.65 298.71,26.65 v298.39,26.96 | v186.16,43.58 v190.55,39.19 | v72.99,57.68 66.4,64.27 66.4,75.87 59.51,82.76 59.51,87.15 D17.C
N$18
  Top 1: D18.C 74,122.08 U$18.SW2
N$19
  Top 1: D76.C 256.32,72.4 253.72,72.4 U$76.SW2
N$20
  Top 1: D87.C 310.93,49.53 310.93,51.1 315.32,55.49 322.53,55.49 U$87.SW2
N$21
  Top 1: D91.C 330.06,49.53 330.06,51.41 334.13,55.49 341.66,55.49 U$91.SW2
N$22
  Bottom 1: D81.C 291.5,64.58 291.5,69.6 296.2,74.3 303.72,74.3 U$81.SW2
N$23  (via drill 0.35)
  Top 1: U$23.SW2 72.14,93.58 D23.C 78.63,87.15 82.38,83.4 v227.31,83.4 | v385.23,26.65 394.95,36.37 403.42,36.37 DUPLICADO3.SW2 | v335.38,29.16 330.68,24.45 v294.94,24.45 | v274.88,44.52 263.91,44.52 261.09,47.34 261.09,52.35 v259.2,54.24
  Bottom 1: v385.23,26.65 337.89,26.65 v335.38,29.16 | v274.88,44.52 v294.94,24.45 | v259.2,54.24 259.2,55.8 249.17,65.83 244.47,65.83 241.65,68.66 241.65,69.07 v227.31,83.4
N$24
  Top 1: D24.C 93,122.08 U$24.SW2
N$25
  Top 1: U$75.SW2 259.89,55.58 D75.C
N$26
  Top 1: U$69.SW2 238.39,55.58 D69.C
N$27
  Top 1: D63.C 219.39,55.58 U$63.SW2
N$28
  Top 1: D57.C 200.39,55.58 U$57.SW2
N$29  (via drill 0.35)
  Top 1: D29.C 91.14,93.58 U$29.SW2 | v341.34,42.01 327.24,27.9 312.5,27.9 311.87,27.27 305.92,27.27 298.55,34.64 279.31,34.64 v278.02,35.92 | v271.73,42.86 210.79,42.86 206.94,46.71 135.37,46.71 132.24,49.85 132.24,50.16 124.71,57.68 v108.72,57.68
  Bottom 1: v341.34,42.01 354.82,55.49 365.48,55.49 DUPLICADO4.SW2 | v278.02,35.92 278.02,37.67 272.83,42.86 v271.73,42.86 | v108.72,57.68 104.34,62.07 104.34,75.87 97.44,82.76 97.44,87.15 D29.C
N$30
  Top 1: D30.C 112,122.08 U$30.SW2
N$37
  Top 1: D51.C 181.39,55.58 U$51.SW2
N$38
  Top 1: D45.C 162.39,55.58 U$45.SW2
N$39
  Top 1: D39.C 143.39,55.58 U$39.SW2
N$40
  Top 1: D33.C 124.39,55.58 U$33.SW2
N$41  (via drill 0.35)
  Top 1: D35.C 110.14,93.58 U$35.SW2 | v342.91,32.92 347.61,37.62 358.27,37.62 370.18,49.53 370.18,58 372.06,59.88 373.32,59.88 377.39,55.8 384.29,55.8 DUPLICADO5.SW2 | v287.42,58 281.15,58 279.58,56.43 266.42,56.43 v263.28,59.56 | v258.26,64.58 112.8,64.58 108.72,68.66 v108.72,77.12
  Bottom 1: v342.91,32.92 335.38,32.92 325.35,42.95 314.69,42.95 308.43,49.22 308.43,53.92 304.66,57.68 287.73,57.68 v287.42,58 | v258.26,64.58 v263.28,59.56 | v108.72,77.12 108.72,79.63 116.25,87.15 D35.C
N$42
  Top 1: D36.C 140.5,122.08 U$36.SW2
N$43
  Top 1: D27.C 105.39,55.58 U$27.SW2
N$44
  Top 1: D21.C 86.39,55.58 U$21.SW2
N$45
  Top 1: D15.C 67.39,55.58 U$15.SW2
N$46
  Top 1: D9.C 48.39,55.58 U$9.SW2
N$47  (via drill 0.35)
  Top 1: D41.C 129.14,93.58 U$41.SW2 | v403.42,58.94 403.42,55.8 DUPLICADO6.SW2 | v419,15.9 416.8,13.7 416.8,8.9 414.17,6.27 389.85,6.27 384.81,11.3 381.1,11.3 378.58,8.78 366.18,8.78 360.41,14.56 354.48,14.56 341.69,1.77 228.39,1.77 227.34,2.82 v191.77,2.82
  Bottom 1: v403.42,58.94 409.69,58.94 417.31,51.31 417.31,35.97 427.17,26.11 427.17,18.97 424.1,15.9 v419,15.9 | v191.77,2.82 166.69,27.9 144.78,27.9 141.96,30.72 141.96,44.52 146.97,49.53 146.97,57.37 142.27,62.07 142.27,75.87 135.37,82.76 135.37,87.15 D41.C
N$48
  Top 1: D42.C 159.5,122.08 U$42.SW2
N$49
  Top 1: D3.C 22.24,55.58 U$3.SW2
N$50
  Top 1: D2.C 17.49,36.58 U$2.SW2
N$51
  Top 1: U$8.SW2 38.89,36.58 D8.C
N$52
  Top 1: U$14.SW2 57.89,36.58 D14.C
N$53  (via drill 0.35)
  Top 1: D47.C 153.59,88.13 | 153.59,88.13 148.14,93.58 U$47.SW2 | v313.33,81.61 312.49,82.45 301.21,82.45 298.8,84.87 289.15,84.87 v286.76,87.26 | 153.59,88.13 161.08,95.62 224.41,95.62 236.32,83.7 248.7,83.7 251,86 260.1,86 262.4,83.7 v277.39,83.7
  Bottom 1: v313.33,81.61 312.93,81.21 312.93,68.54 334.76,46.71 343.54,46.71 353.57,56.74 358.58,56.74 370.18,68.34 370.18,70.54 366.42,74.3 365.8,74.3 DUPLICADO7.SW2 | v286.76,87.26 285.94,86.44 280.12,86.44 v277.39,83.7
N$54
  Top 1: D48.C 178.5,122.08 U$48.SW2
N$55
  Top 1: U$20.SW2 76.89,36.58 D20.C
N$56
  Top 1: U$26.SW2 95.89,36.58 D26.C
N$57
  Top 1: U$32.SW2 115.87,34.5 119,34.5 120.85,32.65 D32.C
N$58
  Top 1: U$38.SW2 133.89,36.58 D38.C
N$59  (via drill 0.35)
  Top 1: D53.C 167.14,93.58 U$53.SW2 | DUPLICADO8.SW2 384.61,74.3 388.05,74.3 402.16,60.19 404.04,60.19 408.2,56.03 408.2,53.7 410.13,51.77 414.53,51.77 417.4,48.9 417.4,30 v413.7,26.3
  Bottom 1: D53.C 173.31,87.15 180.2,80.26 180.2,64.58 189.29,55.49 189.29,49.85 194.62,44.52 194.62,13.79 201.42,7 236,7 238.09,9.09 240.71,9.09 248.03,1.77 329.34,1.77 333.36,5.78 346.36,5.78 350.37,1.77 354.08,1.77 356.43,4.12 356.43,6.29 359.56,9.42 363.87,9.42 365.56,7.73 374.53,7.73 376,9.21 378.99,9.21 381.03,11.25 389.3,11.25 395.53,5.02 414.23,5.02 416.85,7.64 416.85,12.74 412.93,16.66 412.93,25.53 v413.7,26.3
N$60
  Top 1: D54.C 197.5,122.08 U$54.SW2
N$61
  Top 1: D44.C 152.89,36.58 U$44.SW2
N$62
  Top 1: D50.C 171.89,36.58 U$50.SW2
N$63
  Top 1: D56.C 190.89,36.58 U$56.SW2
N$64
  Top 1: D68.C 228.89,36.58 U$68.SW2
N$65  (via drill 0.35)
  Top 1: D59.C 186.14,93.58 U$59.SW2 | v222.84,44.52 213.75,44.52 v199.95,58.31 | v410.5,26.1 415.6,31.2 v415.6,45.9
  Bottom 1: v222.84,44.52 232.56,34.8 232.56,23.2 252.73,3.02 328.81,3.02 332.93,7.14 346.78,7.14 350.89,3.02 353.56,3.02 355.18,4.64 355.18,6.81 359.07,10.7 364.36,10.7 366.08,8.98 374.01,8.98 375.48,10.46 378.48,10.46 380.51,12.5 389.82,12.5 396.05,6.27 413.71,6.27 415.6,8.16 415.6,11.8 410.5,16.9 v410.5,26.1 | v199.95,58.31 199.95,76.18 192.43,83.7 192.43,87.15 D59.C | DUPLICADO9.SW2 403.42,74.3 396.52,74.3 393.7,71.48 393.7,66.78 402.82,57.65 404.65,57.65 409.7,52.6 413.7,52.6 415.6,50.7 v415.6,45.9
N$66
  Top 1: U$60.SW2 225.95,122.13 D60.C
N$67
  Top 1: D74.C 273.63,30.47 267.52,36.58 U$74.SW2
N$68  (via drill 0.35)
  Top 1: D62.C 209.89,36.58 U$62.SW2 | PUNTODUPLICADO.SW2 398.42,22.75 359.28,22.75 356.08,19.55 355.5,19.55 353.4,17.45 353.4,15.27 341.16,3.02 228.91,3.02 v216.26,15.68
  Bottom 1: v216.26,15.68 216.26,30.41 D62.C
N$69
  Top 1: D80.C 291.5,49.53 291.5,50.79 296.2,55.49 303.72,55.49 U$80.SW2
N$70
  Top 1: U$86.SW2 314.18,36.58 310.75,33.15 D86.C
N$71  (via drill 0.35)
  Top 1: D65.C 205.14,93.58 U$65.SW2 | v266.73,37.93 265.16,37.93 264.22,38.87 v252.62,38.87 | v225.35,65.83 222.53,68.66 v222.53,72.42
  Bottom 1: v266.73,37.93 266.73,37.31 288.05,15.99 288.05,12.23 290.47,9.8 294.03,9.8 296.23,7.6 331.62,7.6 332.41,8.39 344.05,8.39 346.7,11.04 346.7,16.8 350.5,20.6 355.31,20.6 359.46,16.45 363.15,16.45 364.3,17.6 374.84,17.6 374.89,17.56 DUPLICADO10.SW2 | v252.62,38.87 252.62,40.07 245.8,46.9 244.3,46.9 241.96,49.24 241.96,53.92 230.05,65.83 v225.35,65.83 | v222.53,72.42 211.55,83.39 211.55,87.15 D65.C
N$72
  Top 1: U$66.SW2 244.95,122.13 D66.C
N$73
  Top 1: D90.C 329.75,14.45 332.88,17.58 U$90.SW2
N$74
  Top 1: D85.C 310.75,15.05 313.28,17.58 U$85.SW2
N$75
  Top 1: D79.C 291.3,14.2 294.68,17.58 U$79.SW2
N$76
  Top 1: D73.C 254.99,17.58 U$73.SW2
N$77
  Top 1: D71.C 224.14,93.58 U$71.SW2
N$78
  Top 1: U$72.SW2 263.95,122.13 D72.C
N$79
  Top 1: D67.C 231.24,17.58 U$67.SW2
N$80
  Top 1: D61.C 207.49,17.58 U$61.SW2
N$81
  Top 1: D55.C 353.5,90 357.08,93.58 U$55.SW2
N$82
  Top 1: D49.C 278.74,17.58 U$49.SW2
N$83
  Top 1: U$77.SW2 243.14,93.58 D77.C
N$84
  Top 1: U$78.SW2 282.95,122.13 D78.C
N$85
  Top 1: D43.C 412.5,57.12 412.5,63 414.53,65.03 U$43.SW2
N$86
  Top 1: D37.C 136.24,17.58 U$37.SW2
N$87
  Top 1: D31.C 412.7,89.62 412.7,92.1 414.18,93.58 U$31.SW2
N$88
  Top 1: D82.C 286.48,64.58 278.01,64.58 277.7,64.89 U$82.SW2
  Bottom 1: D82.C 286.79,64.27 288.99,64.27 293.38,59.88 304.35,59.88 309.68,54.55 309.68,52.98 317.2,45.46 336.01,45.46 343.54,37.93 352.31,37.93 353.57,39.19 384.92,39.19 396.23,27.88 421.75,27.88 ENTERDUPLICADO.SW2
N$89
  Top 1: U$83.SW2 267.19,93.58 D83.C
N$90
  Top 1: D84.C 291.3,90.3 294.28,93.28 303.54,93.28 U$84.SW2
N$91
  Top 1: D25.C 391.5,90 395.08,93.58 U$25.SW2
N$92
  Top 1: D19.C 372.5,89.8 376.28,93.58 U$19.SW2
N$93
  Top 1: D13.C 64.99,17.58 U$13.SW2
N$94
  Top 1: D88.C 310.93,68.66 310.93,70.22 315.01,74.3 322.53,74.3 U$88.SW2
N$95
  Top 1: D89.C 310.75,90.05 314.28,93.58 316.3,93.58 U$89.SW2
N$96
  Top 1: D7.C 41.24,17.58 U$7.SW2
N$97
  Top 1: D1.C 17.5,17.57 U$1.SW2
N$98
  Bottom 1: D92.C 330.06,68.66 330.06,70.22 334.13,74.3 341.66,74.3 U$92.SW2
N$99
  Bottom 1: D93.C 329.75,90.05 333.28,93.58 U$93.SW2
ONOFF
  Top 1: ONOFF.1 LEDSJUMPER.2 425.93,108.93 427.4,110.4 R3.2
PE2  (via drill 0.35)
  Top 0.5: U1.33 360,104.94 360,102.4 361.3,101.1 v363,101.1
  Bottom 0.5: v363,101.1 364.4,101.1 379.11,115.81 R4.2
RESET  (via drill 0.35)
  Top 0.5: U1.13 360.83,119.83 357.01,123.65 351.71,123.65 348.61,120.55 346.4,120.55 343.1,117.25 343.1,112.49 BUTTON.4 339.01,108.4 331.79,108.4 R5.2 328.1,112.09 328.1,121.3 v328.9,122.1
  Bottom 0.5: v328.9,122.1 332.4,125.6 337.53,125.6 J3.3
RX  (via drill 0.35)
  Top 0.5: U1.20 354.81,118 v353.6,118 | v344.5,115 345.8,113.7 345.8,110.3 341.2,105.7 336.6,105.7 333.87,102.97 RXTX.1
  Bottom 0.5: v353.6,118 352.1,116.5 350.9,116.5 348.2,113.8 345.7,113.8 v344.5,115
SCK  (via drill 0.35)
  Top 0.5: J3.6 348.58,123.1 v349.8,124.32 | v354.1,127 365.5,127 368.3,124.2 368.3,122.29 U1.9
  Bottom 0.5: v349.8,124.32 352.48,127 v354.1,127
SCL  (via drill 0.35)
  Top 0.5: U1.18 355.07,120 351.7,120 v350.9,119.2 | SD.2 336.93,102.93 338.1,104.1 344,104.1 346.9,107 v346.9,116.3
  Bottom 0.5: v346.9,116.3 349.8,119.2 v350.9,119.2
SDA  (via drill 0.35)
  Top 0.5: U1.19 354.74,119.2 353.1,119.2 v351.7,117.8 | v347.9,115.1 347.9,106.73 343.47,102.3 SD.1
  Bottom 0.5: v347.9,115.1 350.6,117.8 v351.7,117.8
TX  (via drill 0.35)
  Top 0.5: U1.21 354.77,116.9 352.6,116.9 351.5,115.8 v351.5,114.9 | v344.5,113 344.5,110.5 340.5,106.5 337.8,106.5 337.6,106.5 335.53,106.5 RXTX.2
  Bottom 0.5: v351.5,114.9 349.6,113 v344.5,113
UCAP
  Top 0.5: U1.6 368.7,119.3 368.7,120.1 369.7,121.1 375.1,121.1 375.9,121.9 375.9,125.2 378.2,127.5 388.9,127.5 394.7,121.7 394.7,118.7 396.9,116.5 412,116.5 413,115.5 418,115.5 419.3,116.8 C1-1UF2.1
VCC  (via drill 0.35)
  Top 0.3: v401.9,120.8 402.05,120.95 J1.B4A9 402.05,122.88 402.47,123.3 402.47,124.37 403.9,125.8 405.8,125.8 406.53,125.07 406.53,123.3 406.95,122.88 J1.A4B9 | v412.5,109.5 417.5,109.5 C2-0.1U.1
  Top 0.5: v348.7,119.5 350.45,117.75 350.45,109.8 351.3,108.95 353.83,108.95 U1.24 358.27,113.4 360.6,113.4 | C1-0.1U.1 416.7,100.4 406.7,100.4 401,106.1 401,109.07 392.44,117.63 392.44,120.76 387.96,125.24 379.15,125.24 378.21,124.3 378.21,121.01 373.79,116.59 370.52,116.59 U1.2 368.52,114.6 364,114.6 | 360.6,113.4 362.8,113.4 | 362.8,113.4 364,114.6 | U1.7 364,115.73 364,115.59 | U1.14 364,115.59 | 364,115.59 364,114.6 | 362.8,113.4 363.5,112.7 369.15,112.7 U1.44 | U1.34 361.42,109.12 | 361.42,109.12 360.6,109.94 360.6,113.4 | U1.42 367.6,111.99 367.6,112 364.1,112 361.42,109.32 361.42,109.12 | v302.5,125.7 302.5,125 301.7,124.2 298.7,124.2 297.23,122.73 IC1.24
  Top 1: v420.08,120.67 421.08,119.67 421.08,114.23 419.36,112.5 C3-0.1U.1 C2-0.1U.1 C1-0.1U.1 420.97,101.33 ONOFF.2
  Bottom 0.3: v401.9,120.8 401.9,119.69 X2.VBUS
  Bottom 0.5: v348.7,119.5 347.85,119.5 346.37,120.98 339.61,120.98 J3.2 337.49,121.3 334.3,118.11 R5.1 328.1,119.71 328.1,120.7 325.8,123 311.42,123 308.72,125.7 v302.5,125.7 | X2.VBUS 400.99,114.41 405.9,109.5 v412.5,109.5
  Bottom 1: v420.08,120.67 416.58,120.67 414.86,122.4 C1-1UF1.1
XTAL1  (via drill 0.35)
  Top 0.5: U1.17 355.55,120.65 355.55,122.45 v355.5,122.5 | v372.7,127.9 373.7,126.9 v373.7,125.2 | Y1.2 385.5,119.36 385.5,112.5 388.3,109.7 392.7,109.7 394.9,111.9 C1-22PF2.1
  Bottom 0.5: v355.5,122.5 356.45,123.45 356.45,124.61 359.69,127.86 372.66,127.86 v372.7,127.9 | v373.7,125.2 373.7,124.1 374.9,122.9 Y1.2
XTAL2  (via drill 0.35)
  Top 0.5: U1.16 357,120.33 357,121.7 v357.2,121.9 | C1-22PF1.1 386.84,114.66 Y1.1
  Bottom 0.5: v357.2,121.9 357.2,124.3 359.9,127 382.74,127 Y1.1

## Text on the board
tPlace: GND | VCC | RESET | MOSI | MISO | SCK | 10K | 1K | 22 | 22 | JMP | TX | RX | SCL | SDA | A0 | A1 | A2 | A3 | A4 | A5